Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2022-12-02T08:40:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.70.2 - Exporter 21.1.70.2 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 02 08:40:59 2022 * Host: PC-FIM14 * Database: C:\Users\tecnico3\AppData\Local\Temp\153c0fa2-fa2f-41e7-9374-f6f7a03a26ce\3aee6609-f2a1-4805-be3d-2433853af43e\ifc * Database version: 5507 * Database creation date: Fri Dec 02 08:40:53 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 02 08:40:53 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 02 08:40:53 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Via ## Città (Provincia) C.A.P.; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Via ## Città (Provincia) C.A.P.; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Cerchio: M_Estremità del livello - Cerchio; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Estremità 8 mm; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: Livello: Estremità 8 mm; Tipo: Livello: Estremità 8 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Estremità 8 mm

# IfcBuildingElementProxy: Famiglia1:Standard, Famiglia1:Standard:209661
In: Livello 1
Type - Material: BIAN
Type - Altro - Categoria: Modelli generici; Nome famiglia: Famiglia1
Type - Dati identità - Descrizione: PAGODA-300-BIAN-C4-FABRIC_TYPE-FABRIC-NOVOL-NOAV-NOCOP-NORUO; Nome del tipo: Standard
Type - Vincoli - Prospetto di default: 0 mm
Type - Pset_BuildingElementProxyCommon - Reference: Standard
Type - Pset_QuantityTakeOff - Reference: Standard
Material: BIAN, FABRIC, SILV
Pset_BuildingElementProxyCommon - sets with these values: 2
Altro - Famiglia: Famiglia1: Standard; Famiglia e tipo: Famiglia1: Standard; ID tipo: Famiglia1: Standard; Tipo: Famiglia1: Standard
Dimensioni - Area: 13.559 m2; Volume: 0.619515 m3
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Nessuno; Offset da host: 0 mm; Quota altimetrica da livello: 0 mm; Sposta con l'oggetto più vicino: no
